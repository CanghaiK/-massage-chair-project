# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\xinlvxueya;..\HARDWARE\usart3;..\HARDWARE\LCD;..\HARDWARE\uart5;..\HARDWARE\STMFLASH;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\IMAGE2LCD;..\HARDWARE\ADC;..\HARDWARE\MALLOC;..\HARDWARE\24CXX;..\HARDWARE\FATFS\src;..\HARDWARE\IIC;..\HARDWARE\TOUCH;..\HARDWARE\SD;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\FATFS\exfuns;..\HARDWARE\TEXT;..\OBJ;..\HARDWARE\USMART;..\HARDWARE\WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/xinlvxueya/: xinlvxueya.c xinlvxueya.h
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../HARDWARE/uart5/: uart5.c uart5.h
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/WIFI/: wifi.c common.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IMAGE2LCD/: image2lcd.c image1.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../HARDWARE/FATFS/src/: ff.c diskio.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c ft5206.c gt9147.c ott2001a.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TEXT/: fontupd.c text.c
    ../HARDWARE/USMART/: usmart.c usmart_config.c usmart_str.c
  group New Group
    ../: README.TXT
